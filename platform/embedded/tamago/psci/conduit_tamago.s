//go:build tamago && arm64

// SPDX-License-Identifier: GPL-3.0-or-later

#include "textflag.h"

TEXT ·callSMC(SB),NOSPLIT|NOFRAME,$0-64
	MOVD	x0+0(FP), R0
	MOVD	x1+8(FP), R1
	MOVD	x2+16(FP), R2
	MOVD	x3+24(FP), R3
	MOVD	ZR, R4
	MOVD	ZR, R5
	MOVD	ZR, R6
	MOVD	ZR, R7
	DSB	$15
	WORD	$0xd4000003 // SMC #0
	DSB	$15
	ISB	$15
	MOVD	R0, r0+32(FP)
	MOVD	R1, r1+40(FP)
	MOVD	R2, r2+48(FP)
	MOVD	R3, r3+56(FP)
	RET

TEXT ·callHVC(SB),NOSPLIT|NOFRAME,$0-64
	MOVD	x0+0(FP), R0
	MOVD	x1+8(FP), R1
	MOVD	x2+16(FP), R2
	MOVD	x3+24(FP), R3
	MOVD	ZR, R4
	MOVD	ZR, R5
	MOVD	ZR, R6
	MOVD	ZR, R7
	DSB	$15
	WORD	$0xd4000002 // HVC #0
	DSB	$15
	ISB	$15
	MOVD	R0, r0+32(FP)
	MOVD	R1, r1+40(FP)
	MOVD	R2, r2+48(FP)
	MOVD	R3, r3+56(FP)
	RET

TEXT ·hasEL2(SB),NOSPLIT|NOFRAME,$0-1
	WORD	$0xd5380400 // MRS X0, ID_AA64PFR0_EL1
	UBFX	$8, R0, $4, R0
	CMP	$0, R0
	CSET	NE, R0
	MOVB	R0, ret+0(FP)
	RET

TEXT ·hasRNDR(SB),NOSPLIT|NOFRAME,$0-1
	WORD	$0xd5380600 // MRS X0, ID_AA64ISAR0_EL1
	LSR	$60, R0, R0
	CMP	$0, R0
	CSET	NE, R0
	MOVB	R0, ret+0(FP)
	RET

TEXT ·readRNDR(SB),NOSPLIT|NOFRAME,$0-9
	WORD	$0xd53b2400 // MRS X0, RNDR (sets PSTATE.Z=0 on valid entropy)
	CSET	NE, R1
	MOVD	R0, val+0(FP)
	MOVB	R1, ok+8(FP)
	RET

TEXT ·readCounter(SB),NOSPLIT|NOFRAME,$0-8
	ISB	$15
	MRS	CNTPCT_EL0, R0
	MOVD	R0, ret+0(FP)
	RET
