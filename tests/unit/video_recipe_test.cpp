// Copyright 2026 FogCast contributors
// SPDX-License-Identifier: GPL-3.0-or-later

#include "native/video_recipe.hpp"

#include <assert.h>
#include <stdio.h>

#include <cstdint>
#include <string>
#include <vector>

namespace {

bool Equal(const std::vector<mister::native::RegisterWrite>& actual,
	const std::vector<mister::native::RegisterWrite>& expected)
{
	if (actual.size() != expected.size()) return false;
	for (std::size_t index = 0; index != actual.size(); ++index) {
		if (actual[index].address != expected[index].address ||
			actual[index].value != expected[index].value) return false;
	}
	return true;
}

void TestMenuRecipeHasExactIdentityProvenanceAndData()
{
	const std::vector<std::uint16_t> expected_timing = {
		0x0020,
		0x0500, 0x006e, 0x0028, 0x00dc,
		0x02d0, 0x0005, 0x0005, 0x0014,
		0x4004, 0x0404, 0x0000,
		0x4003, 0x0000, 0x0001,
		0x4005, 0x0303, 0x0000,
		0x4009, 0x0002, 0x0000,
		0x4008, 0x0007, 0x0000,
		0x4007, 0xc28f, 0xe8f5,
	};
	const std::vector<mister::native::RegisterWrite> expected_initialization = {
		{0x98,0x03},{0xd6,0xc0},{0x41,0x10},{0x9a,0x70},
		{0x9c,0x30},{0x9d,0x61},{0xa2,0xa4},{0xa3,0xa4},
		{0xe0,0xd0},{0x35,0x40},{0x36,0xd9},{0x37,0x0a},
		{0x38,0x00},{0x39,0x2d},{0x3a,0x00},{0x16,0x38},
		{0x17,0x62},{0x3b,0x80},{0x3c,0x00},{0x48,0x08},
		{0x49,0xa8},{0x40,0x00},{0x4a,0x80},{0x4c,0x00},
		{0x55,0x10},{0x56,0x08},{0x57,0x08},{0x59,0x00},
		{0x73,0x01},{0x96,0xff},{0x94,0x00},{0xc9,0x00},
		{0x99,0x02},{0x9b,0x18},{0x9f,0x00},{0xa1,0x00},
		{0xa4,0x08},{0xa5,0x04},{0xa6,0x00},{0xa7,0x00},
		{0xa8,0x00},{0xa9,0x00},{0xaa,0x00},{0xab,0x40},
		{0xaf,0x06},{0xb9,0x00},{0xba,0x60},{0xbb,0x00},
		{0xde,0x9c},{0xe2,0x01},{0xe4,0x60},{0xfa,0x7d},
		{0x0a,0x00},{0x0b,0x0e},{0x0c,0x04},{0x0d,0x10},
		{0x14,0x02},{0x15,0x20},{0x01,0x00},{0x02,0x18},
		{0x03,0x00},{0x07,0x01},{0x08,0x22},{0x09,0x0a},
		{0x18,0xa8},{0x19,0x00},{0x1a,0x00},{0x1b,0x00},
		{0x1c,0x00},{0x1d,0x00},{0x1e,0x00},{0x1f,0x00},
		{0x20,0x00},{0x21,0x00},{0x22,0x08},{0x23,0x00},
		{0x24,0x00},{0x25,0x00},{0x26,0x00},{0x27,0x00},
		{0x28,0x00},{0x29,0x00},{0x2a,0x00},{0x2b,0x00},
		{0x2c,0x08},{0x2d,0x00},{0x2e,0x00},{0x2f,0x00},
		{0xc0,0x00},{0xc1,0x00},{0xc2,0x0f},{0xc3,0xff},
	};
	const std::vector<mister::native::RegisterWrite> expected_mode = {
		{0x17, 0x62}, {0x3b, 0x40}, {0x3c, 0x04},
	};

	const mister::native::VideoRecipe& recipe = mister::native::Menu720p60Recipe();
	assert(std::string(recipe.identity) == "menu_720p60");
	assert(std::string(recipe.source_commit) ==
		"cc5eb4bfc4cb2887dd6ab8364bff7010d7c6978c");
	assert(recipe.timing_words == expected_timing);
	assert(Equal(recipe.adv_initialization, expected_initialization));
	assert(Equal(recipe.adv_mode, expected_mode));
}

} // namespace

int main()
{
	TestMenuRecipeHasExactIdentityProvenanceAndData();
	puts("video_recipe_test: all exact-data assertions passed");
	return 0;
}
